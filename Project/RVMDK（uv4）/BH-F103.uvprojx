# Keil uVision project BH-F103.uvprojx, settings and files
target 拍照 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OV7725 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\FATFS\option;..\..\User\FATFS;..\..\User\delay;..\..\User\onenet\inc;..\..\User\device\inc;..\..\User\EDP;..\..\User\onenet\inc;..\..\User\hwtimer;..\..\User\JPEGENCODE;..\..\User\MALLOC;..\..\User\dht11;..\..\User\flame;..\..\User\warning;..\..\User\beep;..\..\User\adc;..\..\User\IIC;..\..\Freee-RTOS\include;..\..\Freee-RTOS\portable\RVDS\ARM_CM3;..\..\User\IWDG;..\..\User\light_moto;..\..\User\M8266WIFI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/ov7725/: bsp_ov7725.c
    ../../User/sccb/: bsp_sccb.c
    ../../User/led/: bsp_led.c
    ../../User/usart/: bsp_usart.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/sdio/: bsp_sdio_sdcard.c
    ../../User/device/src/: esp8266.c
    ../../User/delay/: delay.c
    ../../User/hwtimer/: hwtimer.c
    ../../User/JPEGENCODE/: encode.c
    ../../User/MALLOC/: malloc.c
    ../../User/warning/: warning.c
    ../../User/light_moto/: light_moto.c
    ../../User/dht11/: dht11.c
    ../../User/flame/: flame.c
    ../../User/IIC/: IIC.c
    ../../User/lcd/: bsp_ili9341_lcd.c
    ../../User/font/: fonts.c
    ../../User/beep/: beep.c
    ../../User/Key/: bsp_key.c
  group Fatfs
    ../../User/FATFS/: diskio.c ff.c
    ../../User/FATFS/option/: ccsbcs.c syscall.c
  group DOC
    ../../Doc/: readme.txt
  group net_protocol
    ../../User/EDP/: EdpKit.c
  group One_net
    ../../User/onenet/src/: onenet.c
  group Free_RTOS
    ../../Freee-RTOS/: timers.c tasks.c queue.c list.c event_groups.c croutine.c
    ../../Freee-RTOS/portable/RVDS/ARM_CM3/: port.c
    ../../Freee-RTOS/portable/MemMang/: heap_4.c
  group M8266
    ../../User/M8266WIFI/: M8266WIFIDrv_STM32F1xx.a M8266.c M8266HostIf.h M8266WIFI_ops.c M8266HostIf_STM32xx.c
